# Repository NAFT-LinkSpace/Explorer_Kit

File README.md:

# Explorer Kit Wiki

ここではExplorer kitに関する作り方及び使い方に関する説明を公開しています．

※Explorer Kitとは，「第20回種子島ロケットコンテスト」CanSat部門遠隔制御カムバックに出場し優勝を果たした機体のキットである．

## 目次
### 1. 概要
  1. [CanSatとは](../../wiki/1_Overview#11-CanSatとは)
  2. [Schrittの特徴](../../wiki/1_Overview#12-Schrittの特徴)
  3. [大会実績](../../wiki/1_Overview#13-大会実績)
  4. [利用にあたって](../../wiki/1_Overview#14-利用にあたって)
### 2. 作り方
  1. [基板の入手方法](../../wiki/2_1_GettingBoard)
  2. [3Dプリンタ素材の入手方法](../../wiki/2_2_Getting3DParts)
  3. [部品の入手方法](../../wiki/2_3_GettingMaterials)
  4. [SIMカードの入手方法](../../wiki/2_4_GettingSIM)
  5. [基板の実装](../../wiki/2_5_MountingBoard)
  6. [構造の組立](../../wiki/2_6_Assembling)
  7. [構造の分解](../../wiki/2_7_Disassembling)
  8. [開発環境構築](../../wiki/2_8_EnvConstruct)
### 3. 使い方
  1. [注意点](../../wiki/3_1_HowToUse)
  2. [コード説明](../../wiki/3_2_CodeExplanation)
  3. [アプリ説明](../../wiki/3_3_AppExplanation)
### 4. 付録
  1. [おすすめの3Dプリンタ](../../wiki/4_1_Recom3DPrinters)
  2. [オプション](../../wiki/4_2_Option)

## KiCad design circuit/circuit_main/Explorer_Kit.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 0.1uF; C_0603_1608Metric
C13, C14, C15, C16, C17, C18, C19: 1uF; C_0603_1608Metric
C20, C21: 10uF; C_0603_1608Metric
C22, C23, C24, C25: 100uF; C_1206_3216Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9: D; D_SOD-123F
D10, D11, D12, D13, D14, D15: RGB_LED; LED_WS2812B-2020_PLCC4_2.0x2.0mm
D16: LED; LED_0603_1608Metric
F1: Polyfuse; Fuse_1206_3216Metric
J1: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
J2: LiPo_3S; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J3: Vattery_4GPi; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J4, J5: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
J6: Flight_Pin; PinHeader_1x02_P2.54mm_Vertical
J7: Fan_connect; PinSocket_1x02_P2.54mm_Vertical
J8: Fan_connect; PinHeader_2x01_P2.54mm_Horizontal
LS1: Speaker; UGCM0603APE_Speaker
M1: Motor_Servo; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
M2, M3: FIT0520; JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal
M4, M5: Fan; PinHeader_1x02_P2.54mm_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8, R9: 100; R_0603_1608Metric
R10, R11: 1k; R_0603_1608Metric
R12, R13, R14, R15, R16, R17, R18, R19, R20, R21: 10k; R_0603_1608Metric
RV1, RV2, RV3: R_Potentiometer_500; Potentiometer_063P
SW1: SW_DPDT_x2; Switch
U1, U2: Dual_N_MOS; Dual_NMOS
U3, U4, U5: LM317_TO-220F; regulator_variable
U6: AP7375; SOT-23-3
U7, U8: AM2837_MD
U9: MCP3421; SOT-23-6_Handsoldering
U10: UltimateGPS
U11: HC-SR04; PinHeader_1x04_P2.54mm_Vertical
U12: BNO055
U13: VL53L1X; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal
U14: BME280; BME280_SMD
U15: SSD1331
U16: SSD1306

Connections:
CLK: J1.23 (GPIO11), U15.3 (SCLK)
CS: J1.26 (GPIO7), U15.7 (CS)
DATA: J1.37 (GPIO26), U15.6 (D/C)
Echo: J1.21 (GPIO9), R15.1, R16.1
EncodeL_A: J1.31 (GPIO6), M3.3 (EncodeA)
EncodeL_B: J1.29 (GPIO5), M3.4 (EncodeB)
EncodeR_A: J1.24 (GPIO8), M2.3 (EncodeA)
EncodeR_B: J1.22 (GPIO25), M2.4 (EncodeB)
Fan_Contrl: J1.27 (GPIO0), R8.1
FlightPin: J1.36 (GPIO16), J6.2, R21.1
GND: J2.2, R13.2, U1.3 (S)
GND_tmp: C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, D10.4 (GND), D11.4 (GND), D12.4 (GND), D13.4 (GND), D14.4 (GND), D15.4 (GND), D16.1 (K), J1.6 (GND), J1.9 (GND), J1.14 (GND), J1.20 (GND), J1.25 (GND), J1.30 (GND), J1.34 (GND), J1.39 (GND), J3.2, M1.3 (-), M2.2 (Encode-), M3.2 (Encode-), R11.2, R16.2, R20.2, R21.2, RV1.3, RV2.3, RV3.3, U1.1 (S), U2.1 (S), U2.3 (S), U6.3 (GND), U7.3 (GND), U8.3 (GND), U9.2 (Vss), U9.6 (Vin-), U10.7 (GND), U11.4 (GND), U12.2 (GND), U12.7 (GND), U13.2 (GND), U14.1 (GND), U14.5 (SDO), U14.7 (GND), U15.1 (VSS), U16.4 (GND)
LED_DATA: D10.1 (DI), J1.12 (GPIO18)
MOSI: J1.19 (GPIO10), U15.4 (SDIN)
MotorL_A: J1.38 (GPIO20), U8.1 (IN_A)
MotorL_B: J1.40 (GPIO21), U8.2 (IN_B)
MotorR_A: J1.35 (GPIO19), U7.1 (IN_A)
MotorR_B: J1.33 (GPIO13), U7.2 (IN_B)
unnamed: D1.2 (A), SW1.1 (A)
unnamed: D1.1 (K), R13.1, U1.2 (G), U1.4 (G)
unnamed: C15.1, D2.2 (A), D3.2 (A), R2.1, U3.2 (VO)
unnamed: C16.1, D4.2 (A), D5.2 (A), R4.1, U4.2 (VO)
unnamed: C18.1, D6.2 (A), D7.2 (A), R6.1, U5.2 (VO)
unnamed: D7.1 (K), F1.1
unnamed: D9.2 (A), LS1.2, R10.2, U2.7 (D), U2.8 (D)
unnamed: D10.3 (DO), D11.1 (DI)
unnamed: D11.3 (DO), D12.1 (DI)
unnamed: D12.3 (DO), D13.1 (DI)
unnamed: D13.3 (DO), D14.1 (DI)
unnamed: D14.3 (DO), D15.1 (DI)
unnamed: D16.2 (A), R14.2
unnamed: J4.1, J5.1
unnamed: J4.2, J5.2
unnamed: J4.3, J5.3
unnamed: J4.4, J5.4
unnamed: J4.5, J5.5
unnamed: J4.6, J5.6
unnamed: J4.7, J5.7
unnamed: J4.8, J5.8
unnamed: J4.9, J5.9
unnamed: J4.10, J5.10
unnamed: J4.11, J5.11
unnamed: J4.12, J5.12
unnamed: J4.13, J5.13
unnamed: J4.14, J5.14
unnamed: J4.15, J5.15
unnamed: J4.16, J5.16
unnamed: J4.17, J5.17
unnamed: J4.18, J5.18
unnamed: J4.19, J5.19
unnamed: J4.20, J5.20
unnamed: J4.21, J5.21
unnamed: J4.22, J5.22
unnamed: J4.23, J5.23
unnamed: J4.24, J5.24
unnamed: J4.25, J5.25
unnamed: J4.26, J5.26
unnamed: J4.27, J5.27
unnamed: J4.28, J5.28
unnamed: J4.29, J5.29
unnamed: J4.30, J5.30
unnamed: J4.31, J5.31
unnamed: J4.32, J5.32
unnamed: J4.33, J5.33
unnamed: J4.34, J5.34
unnamed: J4.35, J5.35
unnamed: J4.36, J5.36
unnamed: J4.37, J5.37
unnamed: J4.38, J5.38
unnamed: J4.39, J5.39
unnamed: J4.40, J5.40
unnamed: J7.1, M4.1 (+), M5.1 (+)
unnamed: J7.2, M4.2 (-), M5.2 (-)
unnamed: J8.2, U2.5 (D), U2.6 (D)
unnamed: C1.1, M2.6 (Motor+), U7.7 (OUT_A), U7.8 (OUT_A)
unnamed: C1.2, M2.1 (Motor-), U7.5 (OUT_B), U7.6 (OUT_B)
unnamed: C3.1, M3.6 (Motor+), U8.7 (OUT_A), U8.8 (OUT_A)
unnamed: C3.2, M3.1 (Motor-), U8.5 (OUT_B), U8.6 (OUT_B)
unnamed: R3.2, RV1.1
unnamed: R5.2, RV2.1
unnamed: R7.2, RV3.1
unnamed: R8.2, R19.2, U2.4 (G)
unnamed: R9.2, R20.1, U2.2 (G)
unnamed: R1.2, SW1.2 (B)
unnamed: U1.5 (D), U1.6 (D), U1.7 (D), U1.8 (D)
unnamed: R2.2, R3.1, RV1.2, U3.1 (ADJ)
unnamed: R4.2, R5.1, RV2.2, U4.1 (ADJ)
unnamed: R6.2, R7.1, RV3.2, U5.1 (ADJ)
unnamed: R11.1, R12.2, U9.1 (Vin+)
unnamed: R15.2, U11.3 (Echo)
RESET_BNO: J1.16 (GPIO23), U12.5 (RESET)
RESET_Display: J1.7 (GPIO4), U15.5 (RES)
RX: J1.10 (GPIO15), U10.5 (TX)
SCL: J1.5 (GPiO3), R17.2, U9.3 (SCL), U12.4 (SCL), U13.4 (SCL), U14.4 (SCK), U16.2 (SCL)
SDA: J1.3 (GPIO2), R18.2, U9.4 (SDA), U12.3 (SDA), U13.3 (SDA), U14.3 (SDI), U16.1 (SDA)
Servo_PWM: J1.32 (GPIO12), M1.1 (PWM)
Speaker: J1.18 (GPIO24), R9.1
TX: J1.8 (GPIO14), U10.6 (RX)
Trig: J1.28 (GPIO1), U11.2 (Trig)
VOL_3V3: C11.1, C12.1, J1.1 (3V3), J1.17 (3V3), R17.1, R18.1, U9.5 (Vdd), U12.1 (VIN), U14.2 (CSB), U14.6 (VDDIO), U14.8 (VDD)
VOL_3V3_LiPo: C20.1, D8.2 (A), D9.1 (K), J6.1, LS1.1, M2.5 (Encode+), M3.5 (Encode+), R10.1, R19.1, U6.2 (VO), U10.8 (VIN), U13.1 (+V), U15.2 (VDD), U16.3 (VCC)
VOL_5V: J1.2 (5V), J1.4 (5V)
VOL_5V_LiPo: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C21.1, D10.2 (VDD), D11.2 (VDD), D12.2 (VDD), D13.2 (VDD), D14.2 (VDD), D15.2 (VDD), F1.2, J8.1, M1.2 (+), U11.1 (VCC)
VOL_6V_M1: C2.1, C22.1, C23.1, D3.1 (K), U7.4 (VCC)
VOL_6V_M2: C4.1, C24.1, C25.1, D5.1 (K), U8.4 (VCC)
VOL_11.1V: C13.1, C14.1, C17.1, C19.1, D2.1 (K), D4.1 (K), D6.1 (K), D8.1 (K), J2.1, J3.1, R1.1, R12.1, R14.1, U3.3 (VI), U4.3 (VI), U5.3 (VI), U6.1 (VI)

Notes on the sheet:
電源回路
装飾・その他
センサーモジュール
駆動部
4GPi_V-Control
セラミックコンデンサ直付けする
4GPi_V-condition
ラズパイとの接続
4GPi_reset

Board: 2 copper layers, 85.0 x 52.0 mm, 92 parts (53 on the bottom side), 64 nets.

## Commit log

2024-11-02 ラズパイ側のプログラム
2024-11-02 基板データ
2024-11-09 LICENSEとREADMEの追加
2024-11-09 README修正
2024-11-09 README修正2
2024-11-09 README修正3
2024-11-09 READNE修正
2024-11-09 README修正4
2024-11-10 STLデータ
2025-03-26 stlデータ名称変更
